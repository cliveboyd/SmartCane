# Keil uVision project ble_app_1V0-VT100.uvprojx, settings and files
target ble_app_temp (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_temp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_CUSTOM SOFTDEVICE_PRESENT NRF51 DEBUG_NRF_USER SPI_MASTER_0_ENABLE SPI_MASTER_1_ENABLE MPU9250
  c include: .
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x4000
  group Application
    ./: main.c ble_ad7746.c AD7746.c Communication.c sensorADC.c ds2401.c inv_mpu.c A2035H.c nrf_pwm.c ltc2943.c MPL3115.c AT45.c MPU_9250.c NEMAParser.c DS28E02.c
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_advertising 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_debug_assert_handler 2.0.0, nRF_BLE:BLE_Modules:ble_error_log 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Modules:device_manager 2.0.0, nRF_BLE:BLE_Services:ble_nus 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:ble_flash 2.0.0, nRF_Drivers:nrf_adc 2.0.0, nRF_Drivers:nrf_clock 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_drv_common 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_gpiote 2.0.0, nRF_Drivers:nrf_soc 2.0.0, nRF_Drivers:nrf_timer 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Drivers:spi_master 2.0.0, nRF_Drivers:twi_master 2.0.0, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_timer_with_app_scheduler 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nordic_common 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:retarget 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_in_use 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s110 8.0.2, nRF_SoftDevice:s110_hex 8.0.2
